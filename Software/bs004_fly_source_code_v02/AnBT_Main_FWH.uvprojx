# Keil uVision project AnBT_Main_FWH.uvprojx, settings and files
target BS004X_Fly_With_BL (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: AnBT_Main_FWH +hex
  AfterMake: fromelf.exe --bin -o .\output\release\anbt_main_fwh.bin .\output\anbt_main_fwh.axf
  c flags: Optim=1
  c include: .\stm32_lib\inc;.\bs004_lib;.\bs004_user
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group stm32_lib
    ./stm32_lib/src/: stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c stm32f10x_it.c
    ./stm32_lib/startup/: cortexm3_macro.s stm32f10x_vector.s
  group user
    ./bs004_lib/: b_adc.c b_bluetooth.c b_imu.c b_led.c b_motor.c b_mpu6050.c b_parameter.c b_pid.c b_sys.c
    ./bs004_user/: b_main.c
