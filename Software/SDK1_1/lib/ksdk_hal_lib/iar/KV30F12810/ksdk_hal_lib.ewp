# IAR project ksdk_hal_lib.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKV30F128xxx10 Freescale MKV30F128xxx10
  ICCARM.CCDefines: DEBUG; CPU_MKV30F128VLH10; IAR; TWR_KV30F100M; TOWER
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../../../platform/CMSIS/Include; ../../../../platform/CMSIS/Include/device; ../../../../platform/startup/MKV30F12810; ../../../../platform/utilities/inc; ../../../../platform/hal/inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: psp_arm.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKV30F128VLH10; IAR; TWR_KV30F100M; TOWER
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: libgeneric.out
  group platform/hal/adc16
    ../../../../platform/hal/src/adc16/: fsl_adc16_hal.c
    ../../../../platform/hal/inc/: fsl_adc16_hal.h
  group platform/hal/cmp
    ../../../../platform/hal/src/cmp/: fsl_cmp_hal.c
    ../../../../platform/hal/inc/: fsl_cmp_hal.h
  group platform/hal/dac
    ../../../../platform/hal/src/dac/: fsl_dac_hal.c
    ../../../../platform/hal/inc/: fsl_dac_hal.h
  group platform/hal/dmamux
    ../../../../platform/hal/src/dmamux/: fsl_dmamux_hal.c
    ../../../../platform/hal/inc/: fsl_dmamux_hal.h
  group platform/hal/edma
    ../../../../platform/hal/inc/: fsl_edma_hal.h
    ../../../../platform/hal/src/edma/: fsl_edma_hal.c
  group platform/hal/dspi
    ../../../../platform/hal/src/dspi/: fsl_dspi_hal.c
    ../../../../platform/hal/inc/: fsl_dspi_hal.h
  group platform/hal/ftm
    ../../../../platform/hal/src/ftm/: fsl_ftm_hal.c
    ../../../../platform/hal/inc/: fsl_ftm_hal.h
  group platform/hal/gpio
    ../../../../platform/hal/src/gpio/: fsl_gpio_hal.c
    ../../../../platform/hal/inc/: fsl_gpio_hal.h
  group platform/hal/i2c
    ../../../../platform/hal/src/i2c/: fsl_i2c_hal.c
    ../../../../platform/hal/inc/: fsl_i2c_hal.h
  group platform/hal/llwu
    ../../../../platform/hal/src/llwu/: fsl_llwu_hal.c
    ../../../../platform/hal/inc/: fsl_llwu_hal.h
  group platform/hal/lptmr
    ../../../../platform/hal/src/lptmr/: fsl_lptmr_hal.c
    ../../../../platform/hal/inc/: fsl_lptmr_hal.h
  group platform/hal/mcg
    ../../../../platform/hal/src/mcg/: fsl_mcg_hal.c fsl_mcg_hal_modes.c
    ../../../../platform/hal/inc/: fsl_mcg_hal.h fsl_mcg_hal_modes.h
  group platform/hal/osc
    ../../../../platform/hal/src/osc/: fsl_osc_hal.c
    ../../../../platform/hal/inc/: fsl_osc_hal.h
  group platform/hal/pdb
    ../../../../platform/hal/src/pdb/: fsl_pdb_hal.c
    ../../../../platform/hal/inc/: fsl_pdb_hal.h
  group platform/hal/pit
    ../../../../platform/hal/src/pit/: fsl_pit_hal.c
    ../../../../platform/hal/inc/: fsl_pit_hal.h
  group platform/hal/port
    ../../../../platform/hal/src/port/: fsl_port_hal.c
    ../../../../platform/hal/inc/: fsl_port_hal.h
  group platform/hal/sim
    ../../../../platform/hal/src/sim/MKV30F12810/: fsl_sim_hal_MKV30F12810.c
    ../../../../platform/hal/inc/: fsl_sim_hal.h
  group platform/hal/smc
    ../../../../platform/hal/src/smc/: fsl_smc_hal.c
    ../../../../platform/hal/inc/: fsl_smc_hal.h
  group platform/hal/uart
    ../../../../platform/hal/inc/: fsl_uart_hal.h
    ../../../../platform/hal/src/uart/: fsl_uart_hal.c
  group platform/hal/wdog
    ../../../../platform/hal/src/wdog/: fsl_wdog_hal.c
    ../../../../platform/hal/inc/: fsl_wdog_hal.h
  group platform/hal/pmc
    ../../../../platform/hal/src/pmc/: fsl_pmc_hal.c
    ../../../../platform/hal/inc/: fsl_pmc_hal.h
  group platform/hal/rcm
    ../../../../platform/hal/src/rcm/: fsl_rcm_hal.c
    ../../../../platform/hal/inc/: fsl_rcm_hal.h
