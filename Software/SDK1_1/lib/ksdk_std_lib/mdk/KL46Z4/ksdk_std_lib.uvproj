# Keil uVision project ksdk_std_lib.uvproj, settings and files
target ksdk_std_lib Debug (ARM-ADS)
  device: MKL46Z256xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.1.0
  cpu: IROM(0x00000000,0x8000) IRAM(0x20000000,0x0600) IRAM2(0x1FFFFE00,0x0200) CPUTYPE("Cortex-M0+") CLOCK(48000000) ELITTLE
  output: libksdk_std.lib (library)
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: DEBUG, CPU_MKL46Z256VLL4, KEIL, FRDM_KL46Z48M, FREEDOM
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186 
 --library_interface=armcc  
-J..\..\..\..\utilities\stdlib\include,..\..\..\..\utilities\stdlib\stdio,..\..\..\..\platform\utilities\src  -J#J
  c include: ../../../../utilities/stdlib/include;../../../../utilities/stdlib/stdio;../../../../platform/utilities/src
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x600
  memory RVCT10: RAM 0x1ffffe00 size 0x200
  group std-include
    ../../../../utilities/stdlib/include/: strings.h std_prv.h stdio.h
  group std-stdio
    ../../../../utilities/stdlib/stdio/: buf_prv.c buf_prv.h err.c fclose.c fflush.c fopen.c fread.c fwrite.c get.c pos.c print.c put.c scan.c stdio.c std_prv.c
    ../../../../platform/utilities/src/: print_scan.c print_scan.h
  group std-strings
    ../../../../utilities/stdlib/strings/: strings.c
target ksdk_std_lib Release (ARM-ADS)
  device: MKL46Z256xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.1.0
  cpu: as above
  output: libksdk_std.lib (library)
  c flags: Optim=4 OneElfS=1
  c define: NDEBUG, CPU_MKL46Z256VLL4, KEIL, FRDM_KL46Z48M, FREEDOM
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186  
 --library_interface=armcc  
-J..\..\..\..\utilities\stdlib\include,..\..\..\..\utilities\stdlib\stdio,..\..\..\..\platform\utilities\src  -J#J
  c include: as above
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x600
  memory RVCT10: RAM 0x1ffffe00 size 0x200
