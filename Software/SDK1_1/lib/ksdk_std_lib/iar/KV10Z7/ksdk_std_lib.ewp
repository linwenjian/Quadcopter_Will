# IAR project ksdk_std_lib.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKV10Z32xxx7 Freescale MKV10Z32xxx7
  ICCARM.CCDefines: DEBUG; CPU_MKV10Z32VLF7; IAR; TWR_KV10Z75M; TWR
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../../../utilities/stdlib/include; ../../../../utilities/stdlib/stdio; ../../../../platform/utilities/src
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: psp_arm.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKV10Z32VLF7; IAR; TWR_KV10Z75M; TWR
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: libgeneric.out
  group std/include
    ../../../../utilities/stdlib/include/: strings.h std_prv.h stdio.h
  group std/stdio
    ../../../../utilities/stdlib/stdio/: buf_prv.c buf_prv.h err.c fclose.c fflush.c fopen.c fread.c fwrite.c get.c pos.c print.c put.c scan.c stdio.c std_prv.c
    ../../../../platform/utilities/src/: print_scan.c print_scan.h
  group std/strings
    ../../../../utilities/stdlib/strings/: strings.c
