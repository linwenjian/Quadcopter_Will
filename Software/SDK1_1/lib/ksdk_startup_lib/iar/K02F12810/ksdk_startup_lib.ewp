# IAR project ksdk_startup_lib.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK02FN64xx10 Freescale MK02FN64xx10
  ICCARM.CCDefines: DEBUG; CPU_MK02FN64VLH10; IAR
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../../../platform/startup/MK02F12810; ../../../../platform/CMSIS/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: psp_arm.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK02FN64VLH10; IAR
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: libgeneric.out
  group startup
    ../../../../platform/startup/MK02F12810/iar/: startup_MK02F12810.s
    ../../../../platform/startup/MK02F12810/: system_MK02F12810.c
    ../../../../platform/startup/: startup.c startup.h
