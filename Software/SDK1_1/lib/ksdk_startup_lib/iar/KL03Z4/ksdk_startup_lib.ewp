# IAR project ksdk_startup_lib.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL03Z32xxx4 Freescale MKL03Z32xxx4
  ICCARM.CCDefines: DEBUG; CPU_MKL03Z32VFK4; IAR; FRDM_KL03Z48M; FREEDOM
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../../../platform/startup/MKL03Z4; ../../../../platform/CMSIS/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: psp_arm.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKL03Z32VFK4; IAR; FRDM_KL03Z48M; FREEDOM
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: libgeneric.out
  group startup
    ../../../../platform/startup/MKL03Z4/iar/: startup_MKL03Z4.s
    ../../../../platform/startup/MKL03Z4/: system_MKL03Z4.c
    ../../../../platform/startup/: startup.c startup.h
