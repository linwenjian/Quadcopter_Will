# Keil uVision project ksdk_startup_lib.uvproj, settings and files
target ksdk_startup_lib Debug (ARM-ADS)
  device: MKV30F128xxx10 Freescale
  output: libksdk_startup.lib (library)
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: DEBUG, CPU_MKV30F128VLH10, KEIL, TWR_KV30F100M, TOWER
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186 
 --library_interface=armcc
  c include: ../../../../platform/startup/MKV30F12810;../../../../platform/CMSIS/Include
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  group startup
    ../../../../platform/startup/MKV30F12810/arm/: startup_MKV30F12810.s
    ../../../../platform/startup/MKV30F12810/: system_MKV30F12810.c
    ../../../../platform/startup/: startup.c startup.h
target ksdk_startup_lib Release (ARM-ADS)
  device: MKV30F128xxx10 Freescale
  output: libksdk_startup.lib (library)
  c flags: Optim=4 OneElfS=1
  c define: NDEBUG, CPU_MKV30F128VLH10, KEIL, TWR_KV30F100M, TOWER
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186  
 --library_interface=armcc
  c include: as above
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
