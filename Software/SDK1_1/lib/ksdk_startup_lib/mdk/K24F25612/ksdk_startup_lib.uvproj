# Keil uVision project ksdk_startup_lib.uvproj, settings and files
target ksdk_startup_lib Debug (ARM-ADS)
  device: MK24FN256xxx12 Freescale
  output: libksdk_startup.lib (library)
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: DEBUG, CPU_MK24FN256VDC12, KEIL, TWR_K24F120M, TOWER
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186 
 --library_interface=armcc
  c include: ../../../../platform/startup/MK24F25612;../../../../platform/CMSIS/Include
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  group startup
    ../../../../platform/startup/MK24F25612/arm/: startup_MK24F25612.s
    ../../../../platform/startup/MK24F25612/: system_MK24F25612.c
    ../../../../platform/startup/: startup.c startup.h
target ksdk_startup_lib Release (ARM-ADS)
  device: MK24FN256xxx12 Freescale
  output: libksdk_startup.lib (library)
  c flags: Optim=4 OneElfS=1
  c define: NDEBUG, CPU_MK24FN256VDC12, KEIL, TWR_K24F120M, TOWER
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186  
 --library_interface=armcc
  c include: as above
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
