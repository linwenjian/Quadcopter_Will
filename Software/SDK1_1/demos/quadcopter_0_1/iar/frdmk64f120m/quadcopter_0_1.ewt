<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>board</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\boards\frdmk64f120m\board.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\boards\frdmk64f120m\gpio_pins.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\boards\frdmk64f120m\gpio_pins.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\boards\frdmk64f120m\hardware_init.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\boards\frdmk64f120m\pin_mux.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\boards\frdmk64f120m\pin_mux.h</name>
    </file>
  </group>
  <group>
    <name>source</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\platform\drivers\src\adc16\fsl_adc16_irq.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\platform\drivers\src\i2c\fsl_i2c_irq.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\quad_common.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\quad_i2c_acce_interrupt.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\quad_i2c_config.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\quad_send_data.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\src\quadcopter_main.c</name>
    </file>
  </group>
  <group>
    <name>startup</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\platform\startup\startup.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\platform\startup\startup.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\platform\startup\MK64F12\iar\startup_MK64F12.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\platform\startup\MK64F12\system_MK64F12.c</name>
    </file>
  </group>
  <group>
    <name>utilities</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\platform\utilities\src\fsl_debug_console.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\platform\utilities\inc\fsl_debug_console.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\platform\utilities\src\print_scan.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\platform\utilities\src\print_scan.h</name>
    </file>
  </group>
</project>


