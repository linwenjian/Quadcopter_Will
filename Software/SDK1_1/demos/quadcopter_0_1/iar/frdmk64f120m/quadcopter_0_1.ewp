# IAR project quadcopter_0_1.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK64FN1M0xxx12 Freescale MK64FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; CPU_MK64FN1M0VMD12; IAR; FRDM_K64F120M; FREEDOM; Use_X_MODE
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../src; ../../src/DMP; ../../../../platform/utilities/inc; ../../../../platform/osa/inc; ../../../../platform/CMSIS/Include; ../../../../platform/CMSIS/Include/device; ../../../../platform/startup/MK64F12; ../../../../platform/hal/inc; ../../../../platform/drivers/inc; ../../../../platform/drivers/src/i2c; ../../../../platform/system/inc; ../../../../boards/frdmk64f120m
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  OBJCOPY.OOCOutputFile: quadcopter_0_1.srec
  ILINK.IlinkOutputFile: quadcopter_0_1.out
  ILINK.IlinkConfigDefines: __stack_size__=0x2000; __heap_size__=0x2000; __ram_vector_table__=1
  ILINK.IlinkIcfFile: ../../../../platform/linker/MK64F12/iar/MK64FN1M0xxx12_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../lib/ksdk_platform_lib/iar/K64F12/debug/libksdk_platform.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK64FN1M0VMD12; IAR; FRDM_K64F120M; FREEDOM
  ICCARM.CCIncludePath2: ../../src; ../../../../platform/utilities/inc; ../../../../platform/osa/inc; ../../../../platform/CMSIS/Include; ../../../../platform/CMSIS/Include/device; ../../../../platform/startup/MK64F12; ../../../../platform/hal/inc; ../../../../platform/drivers/inc; ../../../../platform/drivers/src/i2c; ../../../../platform/system/inc; ../../../../boards/frdmk64f120m
  ICCARM.CCOptLevel: 3
  ILINK.IlinkAdditionalLibs: ../../../../lib/ksdk_platform_lib/iar/K64F12/release/libksdk_platform.a
  group board
    ../../../../boards/frdmk64f120m/: board.h gpio_pins.c gpio_pins.h hardware_init.c pin_mux.c pin_mux.h
  group source
    ../../../../platform/drivers/src/adc16/: fsl_adc16_irq.c
    ../../../../platform/drivers/src/i2c/: fsl_i2c_irq.c
    ../../src/: quad_common.h quad_i2c_acce_interrupt.c quad_i2c_config.h quad_moter_control.c quad_send_data.h quadcopter_main.c
  group source/DMP
    ../../src/DMP/: dmpKey.h dmpmap.h inv_mpu.c inv_mpu.h inv_mpu_dmp_motion_driver.c inv_mpu_dmp_motion_driver.h mpu6050dmp_attitude_angle_cal.c mpu6050dmp_attitude_angle_cal.h
  group source/imu
    ../../src/: imu.c imu.h
  group startup
    ../../../../platform/startup/: startup.c startup.h
    ../../../../platform/startup/MK64F12/iar/: startup_MK64F12.s
    ../../../../platform/startup/MK64F12/: system_MK64F12.c
  group utilities
    ../../../../platform/utilities/src/: fsl_debug_console.c print_scan.c print_scan.h
    ../../../../platform/utilities/inc/: fsl_debug_console.h
