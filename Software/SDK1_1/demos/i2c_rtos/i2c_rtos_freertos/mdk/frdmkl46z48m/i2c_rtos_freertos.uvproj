# Keil uVision project i2c_rtos_freertos.uvproj, settings and files
target i2c_rtos_freertos Debug (ARM-ADS)
  device: MKL46Z256xxx4 Freescale
  cpu: IRAM(0x1FFFE000-0x1FFFFFFF) IRAM2(0x20000000-0x20005FFF) IROM(0x0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") ELITTLE
  output: i2c_rtos_freertos.out
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: DEBUG, CPU_MKL46Z256VLL4, KEIL, FSL_RTOS_FREE_RTOS, FRDM_KL46Z48M, FREEDOM
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186 
 --library_interface=armcc
  c include: ../../../../../rtos/FreeRTOS/port/mdk;../../../../../rtos/FreeRTOS/config/KL46Z4/mdk;../../../../../rtos/FreeRTOS/include;../../../../../rtos/FreeRTOS/src;../../../../../platform/utilities/inc;../../../../../platform/osa/inc;../../../../../platform/CMSIS/Include;../../../../../platform/CMSIS/Include/device;../../../../../platform/startup/MKL46Z4;../../../../../platform/hal/inc;../../../../../platform/drivers/inc;../../../../../platform/system/inc;../../../src;../../../../../boards/frdmkl46z48m
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  asm include: ../../../../../rtos/FreeRTOS/config/KL46Z4/mdk
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x6000
  scatter file: ../../../../../platform/linker/MKL46Z4/arm/MKL46Z256xxx4_flash.scf
  link misc: ../../../../../lib/ksdk_freertos_lib/mdk/KL46Z4/debug/libksdk_platform_freertos.lib 
--remove 
--predefine="-D__stack_size__=0x2000" 
--predefine="-D__heap_size__=0x2000" 
--predefine="-D__ram_vector_table__=1"
  group free-rtos
    ../../../../../rtos/FreeRTOS/port/mdk/: port.c portasm.S portmacro.h portTicks.h
    ../../../../../rtos/FreeRTOS/include/: croutine.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h semphr.h StackMacros.h task.h timers.h
    ../../../../../rtos/FreeRTOS/src/: croutine.c heap_1.c heap_2.c heap_3.c heap_4.c list.c queue.c tasks.c timers.c event_groups.c
  group utilities
    ../../../../../platform/utilities/src/: fsl_misc_utilities.c fsl_debug_console.c print_scan.c print_scan.h
    ../../../../../platform/utilities/inc/: fsl_debug_console.h
  group startup
    ../../../../../platform/startup/MKL46Z4/arm/: startup_MKL46Z4.s
    ../../../../../platform/startup/MKL46Z4/: system_MKL46Z4.c
    ../../../../../platform/startup/: startup.c startup.h
  group source
    ../../../../../platform/drivers/src/i2c/: fsl_i2c_irq.c
    ../../../src/: i2c_rtos.c task_master.c task_slave.c task_sample.c i2c_rtos.h
  group board
    ../../../../../boards/frdmkl46z48m/: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.h hardware_init.c
target i2c_rtos_freertos Release (ARM-ADS)
  device: MKL46Z256xxx4 Freescale
  cpu: as above
  output: i2c_rtos_freertos.out
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: NDEBUG, CPU_MKL46Z256VLL4, KEIL, FSL_RTOS_FREE_RTOS, FRDM_KL46Z48M, FREEDOM
  c misc: as above
  c include: as above
  asm misc: --cpreproc --diag_suppress=1609,1581
  asm include: ../../../../../rtos/FreeRTOS/config/KL46Z4/mdk
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x6000
  scatter file: as above
  link misc: ../../../../../lib/ksdk_freertos_lib/mdk/KL46Z4/release/libksdk_platform_freertos.lib 
--remove 
--predefine="-D__stack_size__=0x2000" 
--predefine="-D__heap_size__=0x2000" 
--predefine="-D__ram_vector_table__=1"
