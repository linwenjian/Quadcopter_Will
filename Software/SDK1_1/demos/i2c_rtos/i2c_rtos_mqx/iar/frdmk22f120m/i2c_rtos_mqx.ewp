# IAR project i2c_rtos_mqx.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK22FN512xxx12 Freescale MK22FN512xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; CPU_MK22FN512VLH12; IAR; FSL_RTOS_MQX; FRDM_K22F120M; FREEDOM
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../../../../rtos/mqx/lib/frdmk22f120m.iar/debug; ../../../../../rtos/mqx/lib/frdmk22f120m.iar/debug/config; ../../../../../rtos/mqx/lib/frdmk22f120m.iar/debug/mqx; ../../../../../rtos/mqx/lib/frdmk22f120m.iar/debug/mqx_stdlib; ../../../../../rtos/mqx/config/mcu/mk22f120m; ../../../../../rtos/mqx/config/board/frdmk22f120m; ../../../../../boards/common/phyksz8041; ../../../../../platform/startup/MK22F51212; ../../../../../platform/system/inc; ../../../../../platform/hal/inc; ../../../../../platform/drivers/inc; ../../../../../platform/drivers/src/mpu; ../../../../../platform/startup; ../../../../../rtos/mqx/config/common; ../../../../../rtos/mqx/mqx/source/bsp; ../../../../../rtos/mqx/mqx/source/include; ../../../../../platform/utilities/inc; ../../../../../platform/osa/inc; ../../../../../platform/CMSIS/Include; ../../../../../platform/CMSIS/Include/device; ../../../../../platform/startup/MK22F51212; ../../../../../platform/hal/inc; ../../../../../platform/drivers/inc; ../../../../../platform/system/inc; ../../../src; ../../../../../rtos/mqx/mqx/source/include; ../../../../../rtos/mqx/mqx/source/bsp; ../../../../../rtos/mqx/config/common; ../../../../../rtos/mqx/mqx/source/nio/drivers/nio_dummy; ../../../../../rtos/mqx/mqx/source/nio/drivers/nio_mem; ../../../../../rtos/mqx/mqx/source/nio/drivers/nio_null; ../../../../../rtos/mqx/mqx/source/nio/drivers/nio_pipe; ../../../../../rtos/mqx/mqx/source/nio/drivers/nio_serial; ../../../../../rtos/mqx/mqx/source/nio/drivers/nio_tfs; ../../../../../rtos/mqx/mqx/source/nio/drivers/nio_tty; ../../../../../platform/drivers/src/uart; ../../../../../platform/drivers/src/i2c; ../../../../../boards/frdmk22f120m
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: i2c_rtos_mqx.out
  ILINK.IlinkConfigDefines: __stack_size__=0x400; __heap_size__=0x400; __ram_vector_table__=1
  ILINK.IlinkIcfFile: ../../../../../platform/linker/MK22F51212/iar/MK22FN512xxx12_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../rtos/mqx/lib/frdmk22f120m.iar/debug/mqx/lib_mqx.a; ../../../../../rtos/mqx/lib/frdmk22f120m.iar/debug/mqx_stdlib/lib_mqx_stdlib.a; ../../../../../lib/ksdk_mqx_lib/iar/K22F51212/debug/libksdk_platform_mqx.a
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK22FN512VLH12; IAR; FSL_RTOS_MQX; FRDM_K22F120M; FREEDOM
  ICCARM.CCIncludePath2: ../../../../../rtos/mqx/lib/frdmk22f120m.iar/release; ../../../../../rtos/mqx/lib/frdmk22f120m.iar/release/config; ../../../../../rtos/mqx/lib/frdmk22f120m.iar/release/mqx; ../../../../../rtos/mqx/lib/frdmk22f120m.iar/release/mqx_stdlib; ../../../../../rtos/mqx/config/mcu/mk22f120m; ../../../../../rtos/mqx/config/board/frdmk22f120m; ../../../../../boards/common/phyksz8041; ../../../../../platform/startup/MK22F51212; ../../../../../platform/system/inc; ../../../../../platform/hal/inc; ../../../../../platform/drivers/inc; ../../../../../platform/drivers/src/mpu; ../../../../../platform/startup; ../../../../../rtos/mqx/config/common; ../../../../../rtos/mqx/mqx/source/bsp; ../../../../../rtos/mqx/mqx/source/include; ../../../../../platform/utilities/inc; ../../../../../platform/osa/inc; ../../../../../platform/CMSIS/Include; ../../../../../platform/CMSIS/Include/device; ../../../../../platform/startup/MK22F51212; ../../../../../platform/hal/inc; ../../../../../platform/drivers/inc; ../../../../../platform/system/inc; ../../../src; ../../../../../rtos/mqx/mqx/source/include; ../../../../../rtos/mqx/mqx/source/bsp; ../../../../../rtos/mqx/config/common; ../../../../../rtos/mqx/mqx/source/nio/drivers/nio_dummy; ../../../../../rtos/mqx/mqx/source/nio/drivers/nio_mem; ../../../../../rtos/mqx/mqx/source/nio/drivers/nio_null; ../../../../../rtos/mqx/mqx/source/nio/drivers/nio_pipe; ../../../../../rtos/mqx/mqx/source/nio/drivers/nio_serial; ../../../../../rtos/mqx/mqx/source/nio/drivers/nio_tfs; ../../../../../rtos/mqx/mqx/source/nio/drivers/nio_tty; ../../../../../platform/drivers/src/uart; ../../../../../platform/drivers/src/i2c; ../../../../../boards/frdmk22f120m
  ICCARM.CCOptLevel: 3
  ILINK.IlinkAdditionalLibs: ../../../../../rtos/mqx/lib/frdmk22f120m.iar/release/mqx/lib_mqx.a; ../../../../../rtos/mqx/lib/frdmk22f120m.iar/release/mqx_stdlib/lib_mqx_stdlib.a; ../../../../../lib/ksdk_mqx_lib/iar/K22F51212/release/libksdk_platform_mqx.a
  group BSP Files
    ../../../../../rtos/mqx/mqx/source/bsp/: bsp.h bsp_config.h init_bsp.c mqx_main.c
    ../../../../../rtos/mqx/mqx/source/include/: mqx.h
  group Config Files
    ../../../../../rtos/mqx/config/mcu/mk22f120m/: mqx_sdk_config.h
    ../../../../../rtos/mqx/config/board/frdmk22f120m/: user_config.h
  group Config Files/Common
    ../../../../../rtos/mqx/config/common/: maximum_config.h small_ram_config.h verif_enabled_config.h
  group utilities
    ../../../../../platform/utilities/src/: fsl_debug_console.c print_scan.c print_scan.h
    ../../../../../platform/utilities/inc/: fsl_debug_console.h
  group source
    ../../../src/: i2c_rtos_irq.c i2c_rtos.c task_master.c task_slave.c task_sample.c i2c_rtos.h
  group board
    ../../../../../boards/frdmk22f120m/: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.h hardware_init.c
