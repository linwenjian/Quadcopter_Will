# Keil uVision project i2c_rtos_mqx.uvproj, settings and files
target i2c_rtos_mqx Debug (ARM-ADS)
  device: MK64FN1M0xxx12 Freescale
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2002FFFF) IROM(0x0-0xFFFFF) CLOCK(12000000) CPUTYPE("Cortex-M4")  FPU2 ELITTLE
  output: i2c_rtos_mqx.out
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: DEBUG, CPU_MK64FN1M0VMD12, KEIL, FSL_RTOS_MQX, FRDM_K64F120M, FREEDOM
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186 
 --library_interface=armcc  
-J../../../../../rtos/mqx/lib/frdmk64f120m.mdk/debug/config -J../../../../../rtos/mqx/lib/frdmk64f120m.mdk/debug/mqx -J../../../../../rtos/mqx/lib/frdmk64f120m.mdk/debug/mqx_stdlib -J#J
  c include: ../../../../../rtos/mqx/lib/frdmk64f120m.mdk/debug;../../../../../rtos/mqx/lib/frdmk64f120m.mdk/debug/config;../../../../../rtos/mqx/lib/frdmk64f120m.mdk/debug/mqx;../../../../../rtos/mqx/lib/frdmk64f120m.mdk/debug/mqx_stdlib;../../../../../rtos/mqx/config/mcu/mk64f120m;../../../../../rtos/mqx/config/board/frdmk64f120m;../../../../../boards/common/phyksz8041;../../../../../platform/startup/MK64F12;../../../../../platform/system/inc;../../../../../platform/hal/inc;../../../../../platform/drivers/inc;../../../../../platform/drivers/src/mpu;../../../../../platform/startup;../../../../../rtos/mqx/config/common;../../../../../rtos/mqx/mqx/source/bsp;../../../../../rtos/mqx/mqx/source/include;../../../../../platform/utilities/inc;../../../../../platform/osa/inc;../../../../../platform/CMSIS/Include;../../../../../platform/CMSIS/Include/device;../../../../../platform/startup/MK64F12;../../../../../platform/hal/inc;../../../../../platform/drivers/inc;../../../../../platform/system/inc;../../../src;../../../../../rtos/mqx/mqx/source/include;../../../../../rtos/mqx/mqx/source/bsp;../../../../../rtos/mqx/config/common;../../../../../rtos/mqx/mqx/source/nio/drivers/nio_dummy;../../../../../rtos/mqx/mqx/source/nio/drivers/nio_mem;../../../../../rtos/mqx/mqx/source/nio/drivers/nio_null;../../../../../rtos/mqx/mqx/source/nio/drivers/nio_pipe;../../../../../rtos/mqx/mqx/source/nio/drivers/nio_serial;../../../../../rtos/mqx/mqx/source/nio/drivers/nio_tfs;../../../../../rtos/mqx/mqx/source/nio/drivers/nio_tty;../../../../../platform/drivers/src/uart;../../../../../platform/drivers/src/i2c;../../../../../boards/frdmk64f120m
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: ../../../../../platform/linker/MK64F12/arm/MK64FN1M0xxx12_flash.scf
  link misc: ../../../../../rtos/mqx/lib/frdmk64f120m.mdk/debug/mqx/lib_mqx.lib 
../../../../../rtos/mqx/lib/frdmk64f120m.mdk/debug/mqx_stdlib/lib_mqx_stdlib.lib 
../../../../../lib/ksdk_mqx_lib/mdk/K64F12/debug/libksdk_platform_mqx.lib 
../../../../../rtos/mqx/lib/frdmk64f120m.mdk/debug/mqx/lib_mqx.lib(boot.o) 
../../../../../rtos/mqx/lib/frdmk64f120m.mdk/debug/mqx/lib_mqx.lib(startup_*.o) 
--remove 
--predefine="-D__stack_size__=0x400" 
--predefine="-D__heap_size__=0x400" 
--predefine="-D__ram_vector_table__=1"
  group utilities
    ../../../../../platform/utilities/src/: fsl_misc_utilities.c fsl_debug_console.c print_scan.c print_scan.h
    ../../../../../platform/utilities/inc/: fsl_debug_console.h
  group BSP Files
    ../../../../../rtos/mqx/mqx/source/bsp/: bsp.h bsp_config.h init_bsp.c mqx_main.c
    ../../../../../rtos/mqx/mqx/source/include/: mqx.h
  group Config Files-Common
    ../../../../../rtos/mqx/config/common/: maximum_config.h small_ram_config.h verif_enabled_config.h
  group Config Files
    ../../../../../rtos/mqx/config/mcu/mk64f120m/: mqx_sdk_config.h
    ../../../../../rtos/mqx/config/board/frdmk64f120m/: user_config.h
  group source
    ../../../src/: i2c_rtos_irq.c i2c_rtos.c task_master.c task_slave.c task_sample.c i2c_rtos.h
  group board
    ../../../../../boards/frdmk64f120m/: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.h hardware_init.c
target i2c_rtos_mqx Release (ARM-ADS)
  device: MK64FN1M0xxx12 Freescale
  cpu: as above
  output: i2c_rtos_mqx.out
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: NDEBUG, CPU_MK64FN1M0VMD12, KEIL, FSL_RTOS_MQX, FRDM_K64F120M, FREEDOM
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186 
 --library_interface=armcc  
-J../../../../../rtos/mqx/lib/frdmk64f120m.mdk/release/config -J../../../../../rtos/mqx/lib/frdmk64f120m.mdk/release/mqx -J../../../../../rtos/mqx/lib/frdmk64f120m.mdk/release/mqx_stdlib -J#J
  c include: ../../../../../rtos/mqx/lib/frdmk64f120m.mdk/release;../../../../../rtos/mqx/lib/frdmk64f120m.mdk/release/config;../../../../../rtos/mqx/lib/frdmk64f120m.mdk/release/mqx;../../../../../rtos/mqx/lib/frdmk64f120m.mdk/release/mqx_stdlib;../../../../../rtos/mqx/config/mcu/mk64f120m;../../../../../rtos/mqx/config/board/frdmk64f120m;../../../../../boards/common/phyksz8041;../../../../../platform/startup/MK64F12;../../../../../platform/system/inc;../../../../../platform/hal/inc;../../../../../platform/drivers/inc;../../../../../platform/drivers/src/mpu;../../../../../platform/startup;../../../../../rtos/mqx/config/common;../../../../../rtos/mqx/mqx/source/bsp;../../../../../rtos/mqx/mqx/source/include;../../../../../platform/utilities/inc;../../../../../platform/osa/inc;../../../../../platform/CMSIS/Include;../../../../../platform/CMSIS/Include/device;../../../../../platform/startup/MK64F12;../../../../../platform/hal/inc;../../../../../platform/drivers/inc;../../../../../platform/system/inc;../../../src;../../../../../rtos/mqx/mqx/source/include;../../../../../rtos/mqx/mqx/source/bsp;../../../../../rtos/mqx/config/common;../../../../../rtos/mqx/mqx/source/nio/drivers/nio_dummy;../../../../../rtos/mqx/mqx/source/nio/drivers/nio_mem;../../../../../rtos/mqx/mqx/source/nio/drivers/nio_null;../../../../../rtos/mqx/mqx/source/nio/drivers/nio_pipe;../../../../../rtos/mqx/mqx/source/nio/drivers/nio_serial;../../../../../rtos/mqx/mqx/source/nio/drivers/nio_tfs;../../../../../rtos/mqx/mqx/source/nio/drivers/nio_tty;../../../../../platform/drivers/src/uart;../../../../../platform/drivers/src/i2c;../../../../../boards/frdmk64f120m
  asm misc: --cpreproc --diag_suppress=1609,1581
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: as above
  link misc: ../../../../../rtos/mqx/lib/frdmk64f120m.mdk/release/mqx/lib_mqx.lib 
../../../../../rtos/mqx/lib/frdmk64f120m.mdk/release/mqx_stdlib/lib_mqx_stdlib.lib 
../../../../../lib/ksdk_mqx_lib/mdk/K64F12/release/libksdk_platform_mqx.lib 
../../../../../rtos/mqx/lib/frdmk64f120m.mdk/release/mqx/lib_mqx.lib(boot.o) 
../../../../../rtos/mqx/lib/frdmk64f120m.mdk/release/mqx/lib_mqx.lib(startup_*.o) 
--remove 
--predefine="-D__stack_size__=0x400" 
--predefine="-D__heap_size__=0x400" 
--predefine="-D__ram_vector_table__=1"
