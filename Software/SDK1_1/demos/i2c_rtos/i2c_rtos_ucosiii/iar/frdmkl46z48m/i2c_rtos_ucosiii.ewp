# IAR project i2c_rtos_ucosiii.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL46Z256xxx4 Freescale MKL46Z256xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; CPU_MKL46Z256VLL4; IAR; FSL_RTOS_UCOSIII; FRDM_KL46Z48M; FREEDOM
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../../../../rtos/uCOSIII/src/uCOS-III/Ports/ARM-Cortex-M0/Generic/IAR; ../../../../../rtos/uCOSIII/src/uC-CPU/ARM-Cortex-M0/IAR; ../../../../../rtos/uCOSIII/src/config; ../../../../../rtos/uCOSIII/src/uCOS-III/Source; ../../../../../rtos/uCOSIII/src/uC-CPU; ../../../../../rtos/uCOSIII/src/uC-LIB; ../../../../../platform/utilities/inc; ../../../../../platform/osa/inc; ../../../../../platform/CMSIS/Include; ../../../../../platform/CMSIS/Include/device; ../../../../../platform/startup/MKL46Z4; ../../../../../platform/hal/inc; ../../../../../platform/drivers/inc; ../../../../../platform/system/inc; ../../../src; ../../../../../boards/frdmkl46z48m
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: i2c_rtos_ucosiii.out
  ILINK.IlinkConfigDefines: __stack_size__=0x2000; __heap_size__=0x2000; __ram_vector_table__=1
  ILINK.IlinkIcfFile: ../../../../../platform/linker/MKL46Z4/iar/MKL46Z256xxx4_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../lib/ksdk_ucosiii_lib/iar/KL46Z4/debug/libksdk_platform_ucosiii.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKL46Z256VLL4; IAR; FSL_RTOS_UCOSIII; FRDM_KL46Z48M; FREEDOM
  ICCARM.CCOptLevel: 3
  ILINK.IlinkAdditionalLibs: ../../../../../lib/ksdk_ucosiii_lib/iar/KL46Z4/release/libksdk_platform_ucosiii.a
  group ucosiii
    ../../../../../rtos/uCOSIII/src/uCOS-III/Ports/ARM-Cortex-M0/Generic/IAR/: os_cpu.h os_cpu_a.asm os_cpu_c.c
    ../../../../../rtos/uCOSIII/src/uC-CPU/ARM-Cortex-M0/IAR/: cpu_c.c cpu_a.asm
    ../../../../../rtos/uCOSIII/src/config/: os_app_hooks.c
    ../../../../../rtos/uCOSIII/src/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
    ../../../../../rtos/uCOSIII/src/uC-CPU/: cpu_core.c
  group startup
    ../../../../../platform/startup/MKL46Z4/iar/: startup_MKL46Z4.s
    ../../../../../platform/startup/MKL46Z4/: system_MKL46Z4.c
    ../../../../../platform/startup/: startup.c startup.h
  group utilities
    ../../../../../platform/utilities/src/: fsl_debug_console.c print_scan.c print_scan.h
    ../../../../../platform/utilities/inc/: fsl_debug_console.h
  group source
    ../../../../../platform/drivers/src/i2c/: fsl_i2c_irq.c
    ../../../src/: i2c_rtos.c task_master.c task_slave.c task_sample.c i2c_rtos.h
  group board
    ../../../../../boards/frdmkl46z48m/: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.h hardware_init.c
