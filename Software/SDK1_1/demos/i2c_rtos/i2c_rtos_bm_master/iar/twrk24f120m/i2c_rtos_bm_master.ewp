# IAR project i2c_rtos_bm_master.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK24FN256xxx12 Freescale MK24FN256xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; CPU_MK24FN256VDC12; IAR; TWR_K24F120M; TOWER; FSL_RTOS_BM
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../../../../platform/utilities/inc; ../../../../../platform/osa/inc; ../../../../../platform/CMSIS/Include; ../../../../../platform/CMSIS/Include/device; ../../../../../platform/startup/MK24F25612; ../../../../../platform/hal/inc; ../../../../../platform/drivers/inc; ../../../../../platform/system/inc; ../../../src; ../../../../../boards/twrk24f120m
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: i2c_rtos_bm_master.out
  ILINK.IlinkConfigDefines: __stack_size__=0x2000; __heap_size__=0x2000; __ram_vector_table__=1
  ILINK.IlinkIcfFile: ../../../../../platform/linker/MK24F25612/iar/MK24FN256xxx12_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../lib/ksdk_platform_lib/iar/K24F25612/debug/libksdk_platform.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK24FN256VDC12; IAR; TWR_K24F120M; TOWER; FSL_RTOS_BM
  ICCARM.CCOptLevel: 3
  ILINK.IlinkAdditionalLibs: ../../../../../lib/ksdk_platform_lib/iar/K24F25612/release/libksdk_platform.a
  group startup
    ../../../../../platform/startup/MK24F25612/iar/: startup_MK24F25612.s
    ../../../../../platform/startup/MK24F25612/: system_MK24F25612.c system_MK24F25612.h
    ../../../../../platform/startup/: startup.c startup.h
  group utilities
    ../../../../../platform/utilities/src/: fsl_debug_console.c print_scan.c print_scan.h
    ../../../../../platform/utilities/inc/: fsl_debug_console.h
  group source
    ../../../../../platform/drivers/src/i2c/: fsl_i2c_irq.c
    ../../../src/: i2c_rtos.c task_master.c i2c_rtos.h
  group board
    ../../../../../boards/twrk24f120m/: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.h hardware_init.c
